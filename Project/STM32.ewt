<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>startUp</name>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_hd.s</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\&#x8F66;&#x8F7D;&#x79F0;&#x91CD;\&#x6C49;&#x5FB7;&#x79D1;&#x6280;\&#x8F6F;&#x4eF6;\&#x663e;&#x793A;\CMSIS\CM3\DeviceSupport\ST\STM32F10x\stm32f10x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x\system_stm32f10x.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOSV7.2.0</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\croutine.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\FreeRTOS.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\list.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\mpu_wrappers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\portable.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\projdefs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\semphr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\StackMacros.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\task.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\include\timers.h</name>
      </file>
    </group>
    <group>
      <name>portable</name>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\portable\IAR\ARM_CM3\port.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\portable\IAR\ARM_CM3\portasm.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\portable\IAR\ARM_CM3\portmacro.h</name>
        </file>
      </group>
      <group>
        <name>MemMang</name>
        <file>
          <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\portable\MemMang\heap_2.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOSV7.2.0\timers.c</name>
    </file>
  </group>
  <group>
    <name>GUI</name>
    <group>
      <name>inc</name>
    </group>
    <group>
      <name>src</name>
    </group>
  </group>
  <group>
    <name>HalDriver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\hal24LC02B.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halADC12.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halBeep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halButton.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halI2C.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halI2S.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halInfrared.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halLed.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halMCUWait.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halMPU9250.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halnRF24L01P.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halSPI.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halTIM3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\inc\halUltraSound.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\hal24LC02B.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halADC12.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halBeep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halButton.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halI2C.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halI2S.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halInfrared.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halLed.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halMCUWait.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halMPU9250.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halnRF24L01P.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halSPI.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halTIM3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\HalDriver\src\halUltraSound.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32F10x_StdPeriph_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_bkp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_fsmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_sdio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\inc\stm32f10x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\User\inc\basicMotion.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\BCASTTask.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\bottomBoard.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\CRC16.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\CRC8.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\DEMOTask.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\radio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\RADIOTask.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\stm32f10x_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\stm32f10x_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\systemConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\ultraSound.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\User\src\basicMotion.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\BCASTTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\bottomBoard.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\CRC16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\CRC8.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\DEMOTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\radio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\RADIOTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\ultraSound.c</name>
      </file>
    </group>
  </group>
</project>


